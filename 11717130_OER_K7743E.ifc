Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: e0402ed9-91a0-49ef-bb1e-d4c7ce055090, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T23:11:48+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11717130_OER_K7743E:36774300_OER_11717130_K7743E, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Glass, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1770 mm; Depth: 546 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36774300_OER_11717130_K7743E; sets with these values: 2

# IfcDistributionPort, Port_353973_1
Description: Flow; FlowDirection: SOURCEANDSINK
